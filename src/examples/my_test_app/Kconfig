## src/examples/my_test_app/Kconfig
```kconfig
menuconfig EXAMPLES_MY_TEST_APP
	bool "My Test app"
	default n
	---help---
		Enable My Test app
```
